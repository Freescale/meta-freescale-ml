require ssat.inc

PV .= "+git${SRCPV}"
SRCREV = "163516897314d6e0c437a84272e348f278038be3"
