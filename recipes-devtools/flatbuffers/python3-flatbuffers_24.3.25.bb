SUMMARY = "Memory Efficient Serialization Library - Python3 Modules"
DESCRIPTION = "Python runtime library for use with the FlatBuffers serialization format, to read and write data serialized with code generated by flatc."
HOMEPAGE = "https://github.com/google/flatbuffers"
SECTION = "console/tools"
LICENSE = "Apache-2.0"

LIC_FILES_CHKSUM = "file://../LICENSE;md5=3b83ef96387f14655fc854ddc3c6bd57"

SRC_URI = "git://github.com/google/flatbuffers.git;branch=master;protocol=https \
           file://0001-Fixes-LICENSE-file-in-python.patch;patchdir=${UNPACKDIR}/${BP}"
SRCREV = "e6463926479bd6b330cbcf673f7e917803fd5831"
S = "${UNPACKDIR}/${BP}/python"

CVE_PRODUCT = "google:flatbuffers"

RDEPENDS:${PN} = "flatbuffers"

inherit setuptools3
